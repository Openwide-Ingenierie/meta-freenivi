FILESEXTRAPATHS := "${THISDIR}/files"

SRC_URI += "file://defconfig"
