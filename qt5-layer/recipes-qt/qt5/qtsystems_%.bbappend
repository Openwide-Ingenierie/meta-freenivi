DEPENDS_remove = "bluez4"
DEPENDS += "bluez5"
