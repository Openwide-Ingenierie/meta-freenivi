DEPENDS += "cups"

PACKAGECONFIG += "icu examples accessibility"
