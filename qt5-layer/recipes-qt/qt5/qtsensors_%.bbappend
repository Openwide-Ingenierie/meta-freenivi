DEPENDS += "qtsvg"
