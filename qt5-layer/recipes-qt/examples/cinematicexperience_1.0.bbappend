FILESEXTRAPATHS_prepend := "${THISDIR}/cinematicexperience:"

SRC_URI += " \
    file://change-size.patch \
"
