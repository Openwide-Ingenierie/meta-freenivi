FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Fix-build-with-imx6-vivante-egl-drivers.patch"
