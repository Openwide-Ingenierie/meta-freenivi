DEPENDS_remove = "poppler \
	       	  "
