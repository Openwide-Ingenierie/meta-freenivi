# Remove this dependency that add gtk+
DEPENDS_remove = "poppler"
DEPENDS += "lua"
