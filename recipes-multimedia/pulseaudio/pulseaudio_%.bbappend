
PACKAGECONFIG_remove = "bluez4"
PACKAGECONFIG_append = " bluez5"

