INSANE_SKIP_${PN}-examples = "libdir"
