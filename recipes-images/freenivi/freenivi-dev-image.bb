DESCRIPTION = "Freenivi development image."

inherit freenivi-dev-image