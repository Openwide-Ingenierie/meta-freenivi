INSANE_SKIP_${PN}-arm = "libdir"
