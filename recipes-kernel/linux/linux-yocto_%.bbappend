FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://multitouch-hid.cfg"
